# Keil uVision project demo.uvproj, settings and files
target Debug - LM3S6965 (ARM-ADS)
  device: LM3S6965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1
  c define: UART_BUFFERED=1 PART_LM3S6965
  c include: .\StellarisWare;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\lwip\src\include;.\lwip\src\include\ipv4;.\lwip\ports\stellaris\include;..\..\mbmaster\include;.\port;.
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\demo.sct
  group System
    ./Stellarisware/driverlib/rvmdk/: driverlib.lib
    ./rvmdk/: Startup.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
  group Application
    ./StellarisWare/utils/: uartstdio.c
    ./: demo-tcp.c
  group lwIP
    ./lwip/ports/stellaris/: perf.c sys_arch.c
    ./lwip/ports/stellaris/netif/: ETHIsr.c LWIPStack.c
    ./lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ./lwip/src/netif/: etharp.c
  group Configuration
    ./: FreeRTOSConfig.h lwipopts.h
  group MODBUS
    ./port/: mbmconfig.h mbport.h mbportother.c mbporttimer.c mbporttcp.c mbportevent.c mbportserial.c drvserial.c
    ../../mbmaster/tcp/: mbmtcp.c
    ../../mbmaster/: mbm.c
    ../../mbmaster/common/: mbutils.c
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c
    ../../mbmaster/ascii/: mbmascii.c
    ../../mbmaster/rtu/: mbmcrc.c mbmrtu.c
target Debug - LM3S8962 (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1
  c define: UART_BUFFERED=1 PART_LM3S8962 WITH_LWIP
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\demo.sct
