<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>MODBUS</name>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\mbm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\ascii\mbmascii.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\rtu\mbmcrc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfunccoils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncdisc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncfiles.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncholding.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncinput.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncraw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\functions\mbmfuncslaveid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\rtu\mbmrtu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\tcp\mbmtcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\udp\mbmudp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mbmaster\common\mbutils.c</name>
    </file>
  </group>
  <group>
    <name>MODBUS Port</name>
    <file>
      <name>$PROJ_DIR$\Source\port\mbport.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\port\mbportevent.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\port\mbportother.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\port\mbporttcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\port\mbporttimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\port\mbsconfig.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\Source\DDR_COM.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\DDR_M3_FM3_ETH.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\DDR_M_SysTick.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\DDR_MB9BF_UART.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\devdrv.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\dhcp_client.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\dns_client.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\excp.s79</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\ftp_server.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\http_server.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\hw_init.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\kernel_cfg.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\modbus.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\modbus.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\net_cfg.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\net_strlib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\ping_client.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\prst.s79</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\sntp_client.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\vect.s79</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Source\wfi.s79</name>
  </file>
</project>


